# IAR project soft_spi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\STM32F10x_StdPeriph_Lib\CMSIS\DeviceSupport; ..\..\..\STM32F10x_StdPeriph_Lib\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Middleware; ..\..\..\BSP\Include; ..\Application\AppMain\Inc; ..\..\..\Hardware
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Demo.hex
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\STM32F10x_StdPeriph_Lib\CMSIS\DeviceSupport; ..\..\..\STM32F10x_StdPeriph_Lib\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Middleware; ..\..\..\BSP\Include; ..\Application\AppMain\Inc..\..\..\STM32F10x_StdPeriph_Lib\CMSIS\DeviceSupport; ..\..\..\STM32F10x_StdPeriph_Lib\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Middleware; ..\..\..\BSP\Include; ..\Application\AppMain\Inc
  ICCARM.CCOptLevel: 3
  group AppMain
    ../Application/AppMain/Src/: main.c stm32f10x_it.c
  group BSP
    ../../../BSP/Source/: bsp_led.c bsp_simu_spi.c bsp_system.c bsp_systick.c bsp_uart.c
  group CMSIS
    ../../../STM32F10x_StdPeriph_Lib/CMSIS/DeviceSupport/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Hardware/W25Q32
    ../../../Hardware/W25Q32/: w25q32.c
  group Startup
    ../../../STM32F10x_StdPeriph_Lib/CMSIS/Startup/iar/: startup_stm32f10x_md.s
  group STM32F10x_StdPeriph_Driver
    ../../../STM32F10x_StdPeriph_Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
