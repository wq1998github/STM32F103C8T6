# Keil uVision project Demo.uvprojx, settings and files
target Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC5)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\..\STM32F10x_StdPeriph_Lib\CMSIS\CoreSupport;..\..\..\STM32F10x_StdPeriph_Lib\CMSIS\DeviceSupport;..\..\..\STM32F10x_StdPeriph_Lib\STM32F10x_StdPeriph_Driver\inc;..\..\..\BSP\Include;..\..\..\Middleware;..\Application\AppMain\Inc;..\..\..\Middleware\ucosii\Core\Include;..\..\..\Middleware\ucosii\Ports\ARM;..\..\..\Middleware\ucosii\Cfg
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../../STM32F10x_StdPeriph_Lib/CMSIS/Startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../../../STM32F10x_StdPeriph_Lib/CMSIS/CoreSupport/: core_cm3.c core_cm3.h
    ../../../STM32F10x_StdPeriph_Lib/CMSIS/DeviceSupport/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group STM32F10x_StdPeriph_Driver
    ../../../STM32F10x_StdPeriph_Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../../../BSP/Source/: bsp_led.c bsp_systick.c bsp_uart.c
  group AppMain
    ../Application/AppMain/Src/: main.c stm32f10x_it.c
  group ucosii/Core
    ../../../Middleware/ucosii/Core/Source/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.c
  group ucosii/Ports
    ../../../Middleware/ucosii/Ports/ARM/: os_cpu.h os_cpu_a.asm os_dbg.c
    ../../../Middleware/ucosii/Ports/: os_cpu_c.c
  group ucosii/Cfg
    ../../../Middleware/ucosii/Cfg/: app_cfg.h os_cfg.h app_hooks.c
